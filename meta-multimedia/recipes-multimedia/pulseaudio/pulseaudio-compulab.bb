LICENSE = "CLOSED"
LIC_FILES_CHKSUM = ""

require pulseaudio_compulab.inc

FILES_${PN} = " / "
