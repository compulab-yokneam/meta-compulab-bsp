# Enable srt plug-in 
#PACKAGECONFIG_append = " srt "
