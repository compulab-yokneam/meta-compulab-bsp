SRC_URI += "git://gitlab.freedesktop.org/gstreamer/common.git;protocol=https;branch=master;name=common;destsuffix=git/common"
SRCREV_common = "52adcdb89a9eb527df38c569539d95c1c7aeda6e"
