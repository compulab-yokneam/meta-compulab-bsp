# A build conflict error patch
RDEPENDS:${PN}:remove = "networkmanager"
RDEPENDS:remove = "networkmanager"
