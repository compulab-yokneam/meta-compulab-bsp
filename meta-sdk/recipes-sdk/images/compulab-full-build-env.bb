require compulab-full-build-env.inc
