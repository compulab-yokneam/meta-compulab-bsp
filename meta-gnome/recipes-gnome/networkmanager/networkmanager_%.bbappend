RCONFLICTS_${PN}_remove = "connman"
RREPLACES_${PN} = "connman"
