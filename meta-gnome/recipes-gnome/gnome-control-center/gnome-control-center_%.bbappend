do_install:append() {
	rm -rf ${D}/usr/share/polkit-1/rules.d
}
