../../meta-bsp/classes/compulab-bsp.bbclass