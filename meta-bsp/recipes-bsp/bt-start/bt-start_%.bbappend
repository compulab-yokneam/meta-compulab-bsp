FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://bt-start"
COMPATIBLE_MACHINE = "ucm-imx8"
